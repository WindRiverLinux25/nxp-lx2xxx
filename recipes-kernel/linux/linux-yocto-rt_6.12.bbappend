KBRANCH:nxp-lx2xxx  = "v6.12/standard/preempt-rt/nxp-sdk-6.12/nxp-soc"

require linux-yocto-nxp-lx2xxx.inc
